# Keil uVision project th-thread.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: th-thread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\user;..\rtthread\3.0.3\include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../user/: main.c rtconfig.h
  group rtt/ports
    ../rtthread/3.0.3/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../rtthread/3.0.3/include/: rtthw.h
  group rtt/source
    ../rtthread/3.0.3/include/: rtdef.h rtservice.h rtthread.h
    ../rtthread/3.0.3/src/: thread.c scheduler.c
  group doc
    ../doc/: readme.txt
software components: CMSIS:CORE 5.1.1, Device:Startup 2.6.2
